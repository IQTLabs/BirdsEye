options:
  parameters:
    generate_options: qt_gui
    id: birds_eye_squelch_2
    output_language: python
    title: Birds Eye Squelch
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '5790000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: gain_0
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '90'
    value: '45'
  states: {}
- name: gain_0
  id: variable
  parameters:
    value: '10500000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10500000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: threshhold
    orient: Qt.Horizontal
    start: '-100'
    step: '.5'
    stop: '0'
    value: '-30'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '5e-4'
    gate: 'True'
    ramp: '1000'
    threshold: threshold
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1024'
    max_iter: '40000'
    scale: '10'
    type: float
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"num_recv_frames=256,recv_frame_size=16360"'
    bb_gain0: '0'
    bw0: samp_rate
    freq0: center_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '.5'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: RSSI
    max: '100'
    min: '0'
    type: float
    update_time: '0.20'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0, '0']
- [osmosdr_source_0, '0', analog_pwr_squelch_xx_0, '0']

metadata:
  file_format: 1
