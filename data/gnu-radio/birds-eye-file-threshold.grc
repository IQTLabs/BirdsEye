options:
  parameters:
    generate_options: qt_gui
    id: birds_eye_file_threshold
    output_language: python
    title: IQ File Snipper
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '5745000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: threshhold
    orient: Qt.Horizontal
    start: '-110'
    step: '.5'
    stop: '0'
    value: '-29'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: threshold
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /media/oem/data/data/test-cut-a-1raw
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /media/oem/data/data/set-4/birds-eye-dji-p3-5745MHz-lp-400m-90gain-45deg.raw
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    int_max: '-40'
    int_min: '-105'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_file_sink_0, '0']
- [analog_pwr_squelch_xx_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', analog_pwr_squelch_xx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
